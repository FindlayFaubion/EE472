<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Demo files</name>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\IntQueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\IntQueueTimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ParTest\ParTest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timertest.c</name>
    </file>
  </group>
  <group>
    <name>Library files</name>
    <file>
      <name>$PROJ_DIR$\..\Common\drivers\LuminaryMicro\IAR\driverlib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\formike128x128x16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\drivers\LuminaryMicro\IAR\grlib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\osram128x64x4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rit128x96x4.c</name>
    </file>
  </group>
  <group>
    <name>Scheduler files</name>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM3\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM3\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
  </group>
  <group>
    <name>System files</name>
    <file>
      <name>$PROJ_DIR$\startup_ewarm.c</name>
    </file>
  </group>
  <group>
    <name>uIP files</name>
    <file>
      <name>$PROJ_DIR$\webserver\emac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\webserver\http-strings.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\webserver\httpd-cgi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\webserver\httpd-fs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\webserver\httpd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\ethernet\uIP\uip-1.0\uip\psock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\ethernet\uIP\uip-1.0\uip\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\ethernet\uIP\uip-1.0\uip\uip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\ethernet\uIP\uip-1.0\uip\uip_arp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\webserver\uIP_Task.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\functions.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\functions.h</name>
  </file>
</project>


